# Keil uVision project PID_STM32F103.uvprojx, settings and files
target PID (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PID_STM32F103 +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Drivers;.\User;.\System\Libraries\CMSIS\CM3\CoreSupport;.\System\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\System\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./User/: main.c Hardware.c
  group BoardSupport
    ./Drivers/: AMES_PID.c AMES_FIR.c AMES_CLOCK.c AMES_USART.c AMES_PWM.c AMES_ACS712.c AMES_TIMER.c
    ./User/: AMES_Delay.c
  group Libraries
    ./System/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group CMSIS
    ./System/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./System/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./System/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
